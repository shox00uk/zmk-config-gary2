## boards/shields/Kconfig.defconfig
```kconfig
config ZMK_KEYBOARD_NAME
    default "F.MAN"

CONFIG_ZMK_BLE_CLEAR_BONDS_ON_START y
```
